OBMC_IMAGE_EXTRA_INSTALL_append_evb-ast2500 = " rust-hello"
OBMC_IMAGE_EXTRA_INSTALL_append_evb-ast2500 = " spitransport-tool"
OBMC_IMAGE_EXTRA_INSTALL_append_evb-ast2500 = " otpilot-tool"
